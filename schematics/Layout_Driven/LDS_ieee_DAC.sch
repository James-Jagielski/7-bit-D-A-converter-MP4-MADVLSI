v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1900 80 2260 80 {
lab=#net32}
N 2160 170 2200 170 {
lab=Ibias}
N 2060 170 2100 170 {
lab=#net33}
N 1960 170 2000 170 {
lab=Ibias}
N 1980 100 2180 100 {
lab=Ibias}
N 2160 340 2200 340 {
lab=#net33}
N 2060 340 2100 340 {
lab=Idump}
N 1960 340 2000 340 {
lab=#net33}
N 1980 290 1980 340 {
lab=#net33}
N 1980 290 2180 290 {
lab=#net33}
N 2180 290 2180 340 {
lab=#net33}
N 2080 170 2080 290 {
lab=#net33}
N 1900 340 1900 420 {
lab=Iout}
N 1900 420 2260 420 {
lab=Iout}
N 2260 340 2260 420 {
lab=Iout}
N 1860 170 1900 170 {
lab=#net32}
N 1800 140 1800 170 {
lab=Idump}
N 1800 140 1830 140 {
lab=Idump}
N 2260 170 2300 170 {
lab=#net32}
N 2330 140 2360 140 {
lab=Idump}
N 2360 140 2360 170 {
lab=Idump}
N 1800 310 1800 340 {
lab=Idump}
N 1800 310 1830 310 {
lab=Idump}
N 1860 340 1900 340 {
lab=Iout}
N 2260 340 2300 340 {
lab=Iout}
N 2330 310 2360 310 {
lab=Idump}
N 2360 310 2360 340 {
lab=Idump}
N 1800 340 1800 380 {
lab=Idump}
N 2330 140 2330 310 {
lab=Idump}
N 1830 140 1830 310 {
lab=Idump}
N 1760 380 1800 380 {
lab=Idump}
N 2260 80 2260 170 {
lab=#net32}
N 2180 100 2180 170 {
lab=Ibias}
N 1980 100 1980 170 {
lab=Ibias}
N 1900 80 1900 170 {
lab=#net32}
N 1930 120 1930 140 {
lab=Vg}
N 1930 120 2230 120 {
lab=Vg}
N 2230 120 2230 140 {
lab=Vg}
N 2130 120 2130 140 {
lab=Vg}
N 2030 120 2030 140 {
lab=Vg}
N 1800 380 1800 440 {
lab=Idump}
N 1800 440 2360 440 {
lab=Idump}
N 2080 340 2080 440 {
lab=Idump}
N 1930 260 1930 310 {
lab=D0}
N 1930 260 2230 260 {
lab=D0}
N 2230 260 2230 310 {
lab=D0}
N 2030 310 2030 400 {
lab=D0b}
N 2030 400 2130 400 {
lab=D0b}
N 2130 310 2130 400 {
lab=D0b}
N 1930 310 1930 480 {
lab=D0}
N 2030 400 2030 480 {
lab=D0b}
N 1760 420 1900 420 {
lab=Iout}
N 1760 120 1930 120 {
lab=Vg}
N 2460 80 2820 80 {
lab=#net34}
N 2720 170 2760 170 {
lab=#net32}
N 2620 170 2660 170 {
lab=#net35}
N 2520 170 2560 170 {
lab=#net32}
N 2540 100 2740 100 {
lab=#net32}
N 2720 340 2760 340 {
lab=#net35}
N 2620 340 2660 340 {
lab=Idump}
N 2520 340 2560 340 {
lab=#net35}
N 2540 290 2540 340 {
lab=#net35}
N 2540 290 2740 290 {
lab=#net35}
N 2740 290 2740 340 {
lab=#net35}
N 2640 170 2640 290 {
lab=#net35}
N 2460 340 2460 420 {
lab=#net36}
N 2460 420 2820 420 {
lab=#net36}
N 2820 340 2820 420 {
lab=#net36}
N 2420 170 2460 170 {
lab=#net34}
N 2360 140 2360 170 {
lab=Idump}
N 2360 140 2390 140 {
lab=Idump}
N 2820 170 2860 170 {
lab=#net34}
N 2890 140 2920 140 {
lab=Idump}
N 2920 140 2920 170 {
lab=Idump}
N 2360 310 2360 340 {
lab=Idump}
N 2360 310 2390 310 {
lab=Idump}
N 2420 340 2460 340 {
lab=#net36}
N 2820 340 2860 340 {
lab=#net36}
N 2890 310 2920 310 {
lab=Idump}
N 2920 310 2920 340 {
lab=Idump}
N 2890 140 2890 310 {
lab=Idump}
N 2390 140 2390 310 {
lab=Idump}
N 2820 80 2820 170 {
lab=#net34}
N 2740 100 2740 170 {
lab=#net32}
N 2540 100 2540 170 {
lab=#net32}
N 2460 80 2460 170 {
lab=#net34}
N 2490 120 2490 140 {
lab=Vg}
N 2490 120 2790 120 {
lab=Vg}
N 2790 120 2790 140 {
lab=Vg}
N 2690 120 2690 140 {
lab=Vg}
N 2590 120 2590 140 {
lab=Vg}
N 2360 440 2920 440 {
lab=Idump}
N 2640 340 2640 440 {
lab=Idump}
N 2490 260 2490 310 {
lab=D1}
N 2490 260 2790 260 {
lab=D1}
N 2790 260 2790 310 {
lab=D1}
N 2590 310 2590 400 {
lab=D1b}
N 2590 400 2690 400 {
lab=D1b}
N 2690 310 2690 400 {
lab=D1b}
N 2490 310 2490 480 {
lab=D1}
N 2590 400 2590 480 {
lab=D1b}
N 2230 120 2490 120 {
lab=Vg}
N 2360 340 2360 440 {
lab=Idump}
N 1760 100 1980 100 {
lab=Ibias}
N 2260 100 2540 100 {
lab=#net32}
N 3020 80 3380 80 {
lab=#net37}
N 3280 170 3320 170 {
lab=#net34}
N 3180 170 3220 170 {
lab=#net38}
N 3080 170 3120 170 {
lab=#net34}
N 3100 100 3300 100 {
lab=#net34}
N 3280 340 3320 340 {
lab=#net38}
N 3180 340 3220 340 {
lab=Idump}
N 3080 340 3120 340 {
lab=#net38}
N 3100 290 3100 340 {
lab=#net38}
N 3100 290 3300 290 {
lab=#net38}
N 3300 290 3300 340 {
lab=#net38}
N 3200 170 3200 290 {
lab=#net38}
N 3020 340 3020 420 {
lab=#net39}
N 3020 420 3380 420 {
lab=#net39}
N 3380 340 3380 420 {
lab=#net39}
N 2980 170 3020 170 {
lab=#net37}
N 2920 140 2920 170 {
lab=Idump}
N 2920 140 2950 140 {
lab=Idump}
N 3380 170 3420 170 {
lab=#net37}
N 3450 140 3480 140 {
lab=Idump}
N 3480 140 3480 170 {
lab=Idump}
N 2920 310 2920 340 {
lab=Idump}
N 2920 310 2950 310 {
lab=Idump}
N 2980 340 3020 340 {
lab=#net39}
N 3380 340 3420 340 {
lab=#net39}
N 3450 310 3480 310 {
lab=Idump}
N 3480 310 3480 340 {
lab=Idump}
N 2920 340 2920 380 {
lab=Idump}
N 3450 140 3450 310 {
lab=Idump}
N 2950 140 2950 310 {
lab=Idump}
N 3380 80 3380 170 {
lab=#net37}
N 3300 100 3300 170 {
lab=#net34}
N 3100 100 3100 170 {
lab=#net34}
N 3020 80 3020 170 {
lab=#net37}
N 3050 120 3050 140 {
lab=#net40}
N 3050 120 3350 120 {
lab=#net40}
N 3350 120 3350 140 {
lab=#net40}
N 3250 120 3250 140 {
lab=#net40}
N 3150 120 3150 140 {
lab=#net40}
N 2920 380 2920 440 {
lab=Idump}
N 2920 440 3480 440 {
lab=Idump}
N 3200 340 3200 440 {
lab=Idump}
N 3050 260 3050 310 {
lab=D2}
N 3050 260 3350 260 {
lab=D2}
N 3350 260 3350 310 {
lab=D2}
N 3150 310 3150 400 {
lab=D2b}
N 3150 400 3250 400 {
lab=D2b}
N 3250 310 3250 400 {
lab=D2b}
N 3050 310 3050 480 {
lab=D2}
N 3150 400 3150 480 {
lab=D2b}
N 3580 80 3940 80 {
lab=#net41}
N 3840 170 3880 170 {
lab=#net37}
N 3740 170 3780 170 {
lab=#net42}
N 3640 170 3680 170 {
lab=#net37}
N 3660 100 3860 100 {
lab=#net37}
N 3840 340 3880 340 {
lab=#net42}
N 3740 340 3780 340 {
lab=Idump}
N 3640 340 3680 340 {
lab=#net42}
N 3660 290 3660 340 {
lab=#net42}
N 3660 290 3860 290 {
lab=#net42}
N 3860 290 3860 340 {
lab=#net42}
N 3760 170 3760 290 {
lab=#net42}
N 3580 340 3580 420 {
lab=#net43}
N 3580 420 3940 420 {
lab=#net43}
N 3940 340 3940 420 {
lab=#net43}
N 3540 170 3580 170 {
lab=#net41}
N 3480 140 3480 170 {
lab=Idump}
N 3480 140 3510 140 {
lab=Idump}
N 3940 170 3980 170 {
lab=#net41}
N 4010 140 4040 140 {
lab=Idump}
N 4040 140 4040 170 {
lab=Idump}
N 3480 310 3480 340 {
lab=Idump}
N 3480 310 3510 310 {
lab=Idump}
N 3540 340 3580 340 {
lab=#net43}
N 3940 340 3980 340 {
lab=#net43}
N 4010 310 4040 310 {
lab=Idump}
N 4040 310 4040 340 {
lab=Idump}
N 4010 140 4010 310 {
lab=Idump}
N 3510 140 3510 310 {
lab=Idump}
N 3940 80 3940 170 {
lab=#net41}
N 3860 100 3860 170 {
lab=#net37}
N 3660 100 3660 170 {
lab=#net37}
N 3580 80 3580 170 {
lab=#net41}
N 3610 120 3610 140 {
lab=#net40}
N 3610 120 3910 120 {
lab=#net40}
N 3910 120 3910 140 {
lab=#net40}
N 3810 120 3810 140 {
lab=#net40}
N 3710 120 3710 140 {
lab=#net40}
N 3480 440 4040 440 {
lab=Idump}
N 3760 340 3760 440 {
lab=Idump}
N 3610 260 3610 310 {
lab=D3}
N 3610 260 3910 260 {
lab=D3}
N 3910 260 3910 310 {
lab=D3}
N 3710 310 3710 400 {
lab=D3b}
N 3710 400 3810 400 {
lab=D3b}
N 3810 310 3810 400 {
lab=D3b}
N 3610 310 3610 480 {
lab=D3}
N 3710 400 3710 480 {
lab=D3b}
N 3350 120 3610 120 {
lab=#net40}
N 3480 340 3480 440 {
lab=Idump}
N 3380 100 3660 100 {
lab=#net37}
N 2820 100 3100 100 {
lab=#net34}
N 4140 80 4500 80 {
lab=#net44}
N 4400 170 4440 170 {
lab=#net45}
N 4300 170 4340 170 {
lab=#net46}
N 4200 170 4240 170 {
lab=#net45}
N 4220 100 4420 100 {
lab=#net45}
N 4400 340 4440 340 {
lab=#net46}
N 4300 340 4340 340 {
lab=Idump}
N 4200 340 4240 340 {
lab=#net46}
N 4220 290 4220 340 {
lab=#net46}
N 4220 290 4420 290 {
lab=#net46}
N 4420 290 4420 340 {
lab=#net46}
N 4320 170 4320 290 {
lab=#net46}
N 4140 340 4140 420 {
lab=#net47}
N 4140 420 4500 420 {
lab=#net47}
N 4500 340 4500 420 {
lab=#net47}
N 4100 170 4140 170 {
lab=#net44}
N 4040 140 4040 170 {
lab=Idump}
N 4040 140 4070 140 {
lab=Idump}
N 4500 170 4540 170 {
lab=#net44}
N 4570 140 4600 140 {
lab=Idump}
N 4600 140 4600 170 {
lab=Idump}
N 4040 310 4040 340 {
lab=Idump}
N 4040 310 4070 310 {
lab=Idump}
N 4100 340 4140 340 {
lab=#net47}
N 4500 340 4540 340 {
lab=#net47}
N 4570 310 4600 310 {
lab=Idump}
N 4600 310 4600 340 {
lab=Idump}
N 4040 340 4040 380 {
lab=Idump}
N 4570 140 4570 310 {
lab=Idump}
N 4070 140 4070 310 {
lab=Idump}
N 4500 80 4500 170 {
lab=#net44}
N 4420 100 4420 170 {
lab=#net45}
N 4220 100 4220 170 {
lab=#net45}
N 4140 80 4140 170 {
lab=#net44}
N 4170 120 4170 140 {
lab=#net48}
N 4170 120 4470 120 {
lab=#net48}
N 4470 120 4470 140 {
lab=#net48}
N 4370 120 4370 140 {
lab=#net48}
N 4270 120 4270 140 {
lab=#net48}
N 4040 380 4040 440 {
lab=Idump}
N 4040 440 4600 440 {
lab=Idump}
N 4320 340 4320 440 {
lab=Idump}
N 4170 260 4170 310 {
lab=D4}
N 4170 260 4470 260 {
lab=D4}
N 4470 260 4470 310 {
lab=D4}
N 4270 310 4270 400 {
lab=D4b}
N 4270 400 4370 400 {
lab=D4b}
N 4370 310 4370 400 {
lab=D4b}
N 4170 310 4170 480 {
lab=D4}
N 4270 400 4270 480 {
lab=D4b}
N 4700 80 5060 80 {
lab=#net49}
N 4960 170 5000 170 {
lab=#net44}
N 4860 170 4900 170 {
lab=#net50}
N 4760 170 4800 170 {
lab=#net44}
N 4780 100 4980 100 {
lab=#net44}
N 4960 340 5000 340 {
lab=#net50}
N 4860 340 4900 340 {
lab=Idump}
N 4760 340 4800 340 {
lab=#net50}
N 4780 290 4780 340 {
lab=#net50}
N 4780 290 4980 290 {
lab=#net50}
N 4980 290 4980 340 {
lab=#net50}
N 4880 170 4880 290 {
lab=#net50}
N 4700 340 4700 420 {
lab=#net51}
N 4700 420 5060 420 {
lab=#net51}
N 5060 340 5060 420 {
lab=#net51}
N 4660 170 4700 170 {
lab=#net49}
N 4600 140 4600 170 {
lab=Idump}
N 4600 140 4630 140 {
lab=Idump}
N 5060 170 5100 170 {
lab=#net49}
N 5130 140 5160 140 {
lab=Idump}
N 5160 140 5160 170 {
lab=Idump}
N 4600 310 4600 340 {
lab=Idump}
N 4600 310 4630 310 {
lab=Idump}
N 4660 340 4700 340 {
lab=#net51}
N 5060 340 5100 340 {
lab=#net51}
N 5130 310 5160 310 {
lab=Idump}
N 5160 310 5160 340 {
lab=Idump}
N 5130 140 5130 310 {
lab=Idump}
N 4630 140 4630 310 {
lab=Idump}
N 5060 80 5060 170 {
lab=#net49}
N 4980 100 4980 170 {
lab=#net44}
N 4780 100 4780 170 {
lab=#net44}
N 4700 80 4700 170 {
lab=#net49}
N 4730 120 4730 140 {
lab=#net48}
N 4730 120 5030 120 {
lab=#net48}
N 5030 120 5030 140 {
lab=#net48}
N 4930 120 4930 140 {
lab=#net48}
N 4830 120 4830 140 {
lab=#net48}
N 4600 440 5160 440 {
lab=Idump}
N 4880 340 4880 440 {
lab=Idump}
N 4730 260 4730 310 {
lab=D5}
N 4730 260 5030 260 {
lab=D5}
N 5030 260 5030 310 {
lab=D5}
N 4830 310 4830 400 {
lab=D5b}
N 4830 400 4930 400 {
lab=D5b}
N 4930 310 4930 400 {
lab=D5b}
N 4730 310 4730 480 {
lab=D5}
N 4830 400 4830 480 {
lab=D5b}
N 4470 120 4730 120 {
lab=#net48}
N 4600 340 4600 440 {
lab=Idump}
N 4500 100 4780 100 {
lab=#net44}
N 5260 80 5620 80 {
lab=#net52}
N 5520 170 5560 170 {
lab=#net49}
N 5420 170 5460 170 {
lab=#net53}
N 5320 170 5360 170 {
lab=#net49}
N 5340 100 5540 100 {
lab=#net49}
N 5520 340 5560 340 {
lab=#net53}
N 5420 340 5460 340 {
lab=#net54}
N 5320 340 5360 340 {
lab=#net53}
N 5340 290 5340 340 {
lab=#net53}
N 5340 290 5540 290 {
lab=#net53}
N 5540 290 5540 340 {
lab=#net53}
N 5440 170 5440 290 {
lab=#net53}
N 5260 340 5260 420 {
lab=#net55}
N 5260 420 5620 420 {
lab=#net55}
N 5620 340 5620 420 {
lab=#net55}
N 5220 170 5260 170 {
lab=#net52}
N 5160 140 5160 170 {
lab=Idump}
N 5160 140 5190 140 {
lab=Idump}
N 5160 310 5160 340 {
lab=Idump}
N 5160 310 5190 310 {
lab=Idump}
N 5220 340 5260 340 {
lab=#net55}
N 5160 340 5160 380 {
lab=Idump}
N 5190 140 5190 310 {
lab=Idump}
N 5620 80 5620 170 {
lab=#net52}
N 5540 100 5540 170 {
lab=#net49}
N 5340 100 5340 170 {
lab=#net49}
N 5260 80 5260 170 {
lab=#net52}
N 5290 120 5290 140 {
lab=#net56}
N 5290 120 5590 120 {
lab=#net56}
N 5590 120 5590 140 {
lab=#net56}
N 5490 120 5490 140 {
lab=#net56}
N 5390 120 5390 140 {
lab=#net56}
N 5160 380 5160 440 {
lab=Idump}
N 5440 340 5440 440 {
lab=#net54}
N 5290 260 5290 310 {
lab=D6}
N 5290 260 5590 260 {
lab=D6}
N 5590 260 5590 310 {
lab=D6}
N 5390 310 5390 400 {
lab=D6b}
N 5390 400 5490 400 {
lab=D6b}
N 5490 310 5490 400 {
lab=D6b}
N 5290 310 5290 480 {
lab=D6}
N 5390 400 5390 480 {
lab=D6b}
N 5060 100 5340 100 {
lab=#net49}
N 5160 440 5440 440 {}
N 3940 100 4220 100 {}
C {madvlsi/nmos3.sym} 1930 170 3 1 {name=MH1
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 170 3 1 {name=MV1
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 170 3 1 {name=MV2
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 170 3 1 {name=MH2
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1930 340 3 1 {name=Mb0
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2030 340 3 1 {name=Mbn0
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 340 3 1 {name=Mbn1
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 340 3 1 {name=Mb1
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 170 3 1 {name=M58
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2330 170 3 1 {name=M59
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 340 3 1 {name=M60
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2330 340 3 1 {name=M61
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 1930 480 3 0 {name=p1 lab=D0}
C {devices/ipin.sym} 2030 480 3 0 {name=p2 lab=D0b}
C {devices/opin.sym} 1760 380 2 0 {name=p21 lab=Idump}
C {devices/opin.sym} 1760 420 2 0 {name=p22 lab=Iout}
C {devices/ipin.sym} 1760 120 0 0 {name=p23 lab=Vg}
C {madvlsi/nmos3.sym} 2490 170 3 1 {name=MH3
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2590 170 3 1 {name=MV4
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2690 170 3 1 {name=MV5
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2790 170 3 1 {name=MH6
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2490 340 3 1 {name=Mb7
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2590 340 3 1 {name=Mbn8
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2690 340 3 1 {name=Mbn9
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2790 340 3 1 {name=Mb10
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 170 3 1 {name=M48
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2890 170 3 1 {name=M49
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 340 3 1 {name=M50
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2890 340 3 1 {name=M51
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 2490 480 3 0 {name=p24 lab=D1}
C {devices/ipin.sym} 2590 480 3 0 {name=p25 lab=D1b}
C {devices/ipin.sym} 1760 100 0 0 {name=p26 lab=Ibias}
C {madvlsi/nmos3.sym} 3050 170 3 1 {name=MH4
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3150 170 3 1 {name=MV6
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3250 170 3 1 {name=MV7
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3350 170 3 1 {name=MH8
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3050 340 3 1 {name=Mb9
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3150 340 3 1 {name=Mbn10
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3250 340 3 1 {name=Mbn11
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3350 340 3 1 {name=Mb12
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2950 170 3 1 {name=M54
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3450 170 3 1 {name=M55
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2950 340 3 1 {name=M56
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3450 340 3 1 {name=M57
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 3050 480 3 0 {name=p27 lab=D2}
C {devices/ipin.sym} 3150 480 3 0 {name=p28 lab=D2b}
C {madvlsi/nmos3.sym} 3610 170 3 1 {name=MH58
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3710 170 3 1 {name=MV59
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3810 170 3 1 {name=MV60
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 170 3 1 {name=MH61
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3610 340 3 1 {name=Mb62
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3710 340 3 1 {name=Mbn63
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3810 340 3 1 {name=Mbn64
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3910 340 3 1 {name=Mb65
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3510 170 3 1 {name=M66
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 170 3 1 {name=M67
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3510 340 3 1 {name=M68
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4010 340 3 1 {name=M69
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 3610 480 3 0 {name=p29 lab=D3}
C {devices/ipin.sym} 3710 480 3 0 {name=p30 lab=D3b}
C {madvlsi/nmos3.sym} 4170 170 3 1 {name=MH5
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4270 170 3 1 {name=MV8
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4370 170 3 1 {name=MV9
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4470 170 3 1 {name=MH10
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4170 340 3 1 {name=Mb11
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4270 340 3 1 {name=Mbn12
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4370 340 3 1 {name=Mbn13
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4470 340 3 1 {name=Mb14
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4070 170 3 1 {name=M62
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4570 170 3 1 {name=M63
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4070 340 3 1 {name=M64
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4570 340 3 1 {name=M65
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 4170 480 3 0 {name=p31 lab=D4}
C {devices/ipin.sym} 4270 480 3 0 {name=p32 lab=D4b}
C {madvlsi/nmos3.sym} 4730 170 3 1 {name=MH66
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4830 170 3 1 {name=MV67
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4930 170 3 1 {name=MV68
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5030 170 3 1 {name=MH69
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4730 340 3 1 {name=Mb70
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4830 340 3 1 {name=Mbn71
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4930 340 3 1 {name=Mbn72
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5030 340 3 1 {name=Mb73
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 170 3 1 {name=M74
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5130 170 3 1 {name=M75
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4630 340 3 1 {name=M76
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5130 340 3 1 {name=M77
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 4730 480 3 0 {name=p33 lab=D5}
C {devices/ipin.sym} 4830 480 3 0 {name=p34 lab=D5b}
C {madvlsi/nmos3.sym} 5290 170 3 1 {name=MH78
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5390 170 3 1 {name=MV79
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5490 170 3 1 {name=MV80
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5590 170 3 1 {name=MH81
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5290 340 3 1 {name=Mb82
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5390 340 3 1 {name=Mbn83
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5490 340 3 1 {name=Mbn84
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5590 340 3 1 {name=Mb85
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5190 170 3 1 {name=M86
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 5190 340 3 1 {name=M88
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 5290 480 3 0 {name=p35 lab=D6}
C {devices/ipin.sym} 5390 480 3 0 {name=p36 lab=D6b}
