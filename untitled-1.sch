v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/dev/git/7-bit-D-A-converter-MP4-MADVLSI/schematics/ieee DAC/Layout_Driven/LDS_ieee_DAC.sym} 80 10 0 0 {name=x1}
C {devices/ipin.sym} 30 -170 1 0 {name=p1 lab=Ibias}
C {devices/opin.sym} 100 120 0 0 {name=p2 lab=GND}
C {devices/ipin.sym} -70 -140 0 0 {name=p3 lab=D0b}
C {devices/ipin.sym} -70 -120 0 0 {name=p4 lab=D0}
C {devices/ipin.sym} -70 -100 0 0 {name=p5 lab=D1b}
C {devices/ipin.sym} -70 -80 0 0 {name=p6 lab=D1}
C {devices/ipin.sym} -70 -60 0 0 {name=p7 lab=D2b}
C {devices/ipin.sym} -70 -40 0 0 {name=p8 lab=D2}
C {devices/ipin.sym} -70 -20 0 0 {name=p9 lab=D3b}
C {devices/ipin.sym} -70 0 0 0 {name=p10 lab=D3}
C {devices/ipin.sym} -70 20 0 0 {name=p11 lab=D4b}
C {devices/ipin.sym} -70 40 0 0 {name=p12 lab=D4}
C {devices/ipin.sym} -70 60 0 0 {name=p13 lab=D5b}
C {devices/ipin.sym} -70 80 0 0 {name=p14 lab=D5}
C {devices/ipin.sym} -70 100 0 0 {name=p15 lab=D6b}
C {devices/ipin.sym} -70 120 0 0 {name=p16 lab=D6}
C {devices/opin.sym} 100 100 0 0 {name=p17 lab=Iout}
C {devices/ipin.sym} 0 -170 1 0 {name=p18 lab=Vg}
